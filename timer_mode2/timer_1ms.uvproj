# Keil uVision project timer_1ms.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: timer_1ms +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: timer_mode2.a51
